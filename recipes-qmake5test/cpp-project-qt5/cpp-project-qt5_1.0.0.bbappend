inherit qmake5test

EXTRA_QMAKEVARS_PRE += "WITH_TESTS=ON"
