inherit cmaketest

EXTRA_OECMAKE += "-DWITH_TESTS=ON"
EXTRA_OECMAKE += "-DCMAKE_BUILD_TYPE=RELWITHDEBINFO"
