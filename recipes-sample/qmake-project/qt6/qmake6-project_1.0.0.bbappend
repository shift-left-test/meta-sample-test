inherit qmaketest

EXTRA_QMAKEVARS_PRE += "WITH_TESTS=ON"
