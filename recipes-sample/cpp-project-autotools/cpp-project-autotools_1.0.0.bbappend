inherit autotoolstest
