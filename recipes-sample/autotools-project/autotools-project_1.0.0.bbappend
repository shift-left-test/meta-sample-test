inherit autotoolstest

EXTRA_OECONF += "--with-test"
