inherit cmaketest

EXTRA_OECMAKE += "-DENABLE_STATIC_ANALYSIS=ON"
EXTRA_OECMAKE += "-DWITH_DEFECT_CODE=ON"
EXTRA_OECMAKE += "-DENABLE_TEST=ON"
EXTRA_OECMAKE += "-DCMAKE_BUILD_TYPE=DEBUG"
