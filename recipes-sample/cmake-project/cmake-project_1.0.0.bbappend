inherit cmaketest

EXTRA_OECMAKE += "-DENABLE_TEST=ON"
EXTRA_OECMAKE += "-DCMAKE_BUILD_TYPE=DEBUG"
