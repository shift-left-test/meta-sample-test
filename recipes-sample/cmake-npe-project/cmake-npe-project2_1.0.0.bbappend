inherit cmaketest

EXTRA_OECMAKE += "-DENABLE_STATIC_ANALYSIS=ON"
EXTRA_OECMAKE += "-DENABLE_TESTING=ON"
EXTRA_OECMAKE += "-DCMAKE_BUILD_TYPE=DEBUG"
