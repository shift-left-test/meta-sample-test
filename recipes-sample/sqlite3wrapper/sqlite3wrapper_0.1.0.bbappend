inherit cmaketest

EXTRA_OECMAKE += "-DWITH_TESTS=ON"
