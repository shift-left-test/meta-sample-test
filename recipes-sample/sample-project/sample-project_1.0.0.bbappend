inherit cmaketest

EXTRA_OECMAKE += "-DENABLE_TEST=ON"
