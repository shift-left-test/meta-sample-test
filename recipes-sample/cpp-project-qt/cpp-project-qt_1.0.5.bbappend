inherit qmaketest

