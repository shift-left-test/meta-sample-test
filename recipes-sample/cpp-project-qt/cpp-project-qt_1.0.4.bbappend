inherit qmaketest

EXTRA_QMAKEVARS_PRE += "CONFIG+=qmakeutils"
