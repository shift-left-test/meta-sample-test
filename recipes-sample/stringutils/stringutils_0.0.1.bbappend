inherit cmaketest

EXTRA_OECMAKE += "-DENABLE_TESTS=ON"
