inherit qmake6test

EXTRA_QMAKEVARS_PRE += "WITH_TESTS=ON"
